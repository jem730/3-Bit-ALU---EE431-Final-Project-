** sch_path: AND.sch
**.subckt AND A B VDD GND Y
*.ipin A
*.ipin B
*.iopin VDD
*.iopin GND
*.opin Y
x1 VDD net1 B A GND NAND
x2 VDD net1 Y GND Inv
**.ends
.end
